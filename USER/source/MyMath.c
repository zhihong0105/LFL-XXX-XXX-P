
#include "MyMath.h"


/*
 ***************************************************************************
 * ??:Sqrt()
 * ??:???
* ????:  M         ????        
 * ????:  N  ?
* ??:
***************************************************************************
 */
u16 Sqrt(u32 M)
 {
     u16 N= 0, i; 
     u32 tmp, ttp;   // ??????? 
    if (M == 0)               // ????,??????0      
        return 0;         
     tmp = (M >> 30);          // ?????:B[m-1]   
     M <<= 2;     
     if (tmp > 1)              // ????1    
     {   
         N ++;                 // ??????1,??????0     
         tmp -= N;     
     } 
     for (i=15; i>0; i--)      // ????15?   
      {         
         N <<= 1;              // ???? 
        tmp <<= 2;
         tmp += (M >> 30);     // ??        
         ttp = N;         
         ttp = (ttp<<1)+1;         
         M <<= 2;         
         if (tmp >= ttp)       // ????        
         {             
           tmp -= ttp;             
           N ++;         
         }     
     }     
     
     return N; 
 }
 